# Keil uVision project gases analysi.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F051C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Gases_analysi_for_HIMI +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: .\Libraries\CMSIS\Device\ST\STM32F0xx\Include;.\Libraries\CMSIS\Device\ST\STM32F0xx\Source;.\Libraries\STM32F0xx_CPAL_Driver\inc;.\Libraries\STM32F0xx_CPAL_Driver\src;.\Libraries\STM32F0xx_StdPeriph_Driver\inc;.\Libraries\STM32F0xx_StdPeriph_Driver\src;.\Libraries\CMSIS\Include;.\DRIVE;.\USER;.\CORE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CORE
    ./CORE/: startup_stm32f0xx.s system_stm32f0xx.c
  group DRIVE
    ./DRIVE/: delay.c rtc.c uart1.c uart2.c Uart_Printf.c gpio.c crc16.c i2c_eeprom.c tim3.c bh1750.c tim14.c tim15 .c tim2.c FM31256.C IR433.c HMI.c adc.c sht10.c PM2_5.c
  group StdPeriph_Driver
    ./Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_dma.c stm32f0xx_gpio.c stm32f0xx_iwdg.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_misc.c
  group USER
    ./USER/: mian.c
